# Keil uVision project project.uvprojx, settings and files
target SmartHome (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F427ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: GD32F4XX,GD32F407,GD32F427
  c misc: --no_multibyte_chars
  c include: ..\..\library\GD32F4xx_standard_peripheral\Include;..\..\library\CMSIS\GD\GD32F4xx\Include;..\..\library\CMSIS;..\..\board\inc;..\..\bsp\inc;..\..\module\inc;..\..\app\inc;..\..\freeRTOS\include;..\..\freeRTOS\portable;..\..\task\inc;..\..\freeRTOS\portable\RVDS\ARM_CM4F;..\..\cJSON
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cmsis
    ../../library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group library
    ../../library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_adc.c gd32f4xx_gpio.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_timer.c gd32f4xx_dma.c
  group board
    ../../board/src/: systick.c board_uart.c board.c gd32f4xx_it.c board_led.c
  group bsp
    ../../bsp/src/: bsp_adc.c bsp_basic_timer.c bsp_led.c bsp_pwm.c bsp_usart.c
  group module
    ../../module/src/: dht11.c relay.c ws2812.c ky037.c mq2.c flame.c hx1838.c fpm383.c su03t.c esp8266.c temt6000.c motor.c dwin.c bmp180.c rc522.c sr602.c tc1508.c beep.c
  group app
    ../../app/src/: main.c freeRTOS.c app_dwin.c app_esp8266.c app_rc522.c app_su03t.c app_fpm383.c app_hx1838.c app_tc1508.c app_motor.c app_relay.c app_ws2812.c
  group freeRTOS_code
    ../../freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS_pottable
    ../../freeRTOS/portable/MemMang/: heap_4.c
    ../../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group task
    ../../task/src/: communication_task.c display_task.c media_task.c safety_task.c sensor_task.c execution_task.c
  group cJSON
    ../../cJSON/: cJSON.c
